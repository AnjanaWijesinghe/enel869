# Keil uVision project project.uvprojx, settings and files
target STM32F103ZG (6220000::V6.22::ARMCLANG)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./code/drivers/: gpio.c clock.c
    ./code/timer/: time.c
    ./code/: main.c
    ./code/servo/: servo.c
    ./code/led/: led.c
    ./code/cli/: cli.c
    ./code/ir/: ir.c test_ir_values.c
  group Headers
    ./code/: main.h
    ./code/timer/: time.h
    ./code/drivers/: gpio.h clock.h
    ./code/servo/: servo.h
    ./code/led/: led.h
    ./code/cli/: cli.h
    ./code/ir/: ir.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
